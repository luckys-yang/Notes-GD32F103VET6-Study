# Keil uVision project Template.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My111 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: .\Libraries\CMSIS\GD\GD32F10x\Include;.\Libraries\CMSIS;.\Libraries\GD32F10x_standard_peripheral\Include;.\User;.\APP\myKEY;.\APP\myLED;.\APP\ALL;.\APP\myUART;.\APP\myTIMEER;.\APP\myADC;.\APP\myRTC;.\APP\myDOG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./User/: gd32f10x_it.c main.c systick.c gd32f10x_libopt.h
  group APP
    ./APP/myLED/: myLED.c
    ./APP/myKEY/: myKEY.c
    ./APP/myUART/: myUart1.c
    ./APP/myTIMEER/: myTIMER.c
    ./APP/myADC/: myADC.c
    ./APP/myRTC/: myRTC.c
    ./APP/myDOG/: myDog.c
  group CMSIS
    ./Libraries/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ./Libraries/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ./Libraries/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
